# IAR project receiver.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nRF51822-QFAC NordicSemi nRF51822-QFAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: BSP_DEFINES_ONLY; BOARD_PCA10028; NRF51
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\components\device; ..\..\..\..\components\libraries\util; ..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\components\drivers_nrf\rtc; ..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\components\drivers_nrf\config; ..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\components\libraries\fifo; ..\..\..\..\components\libraries\uart; ..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\components\drivers_nrf\common; ..\..\..\..\components\properitary_rf\gzll; ..\..\..\..\components\toolchain; ..\..\..\..\components\toolchain\CMSIS\Include; ..\..\..\..\examples\bsp; ..\..\..\..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BSP_DEFINES_ONLY; BOARD_PCA10028; NRF51
  AARM.AUserIncludes: ..\..\..\..\..\config; ..\..\..\..\components\device; ..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\components\drivers_nrf\config; ..\..\..\..\components\toolchain; ..\..\..\..\components\toolchain\CMSIS\Include; ..\bsp; ..\..\..\..\..
  OBJCOPY.OOCOutputFile: nrf51822_xxac.hex
  ILINK.IlinkOutputFile: nrf51822_xxac.out
  ILINK.IlinkIcfFile: receiver.icf
  ILINK.IlinkAdditionalLibs: D:\Projects\home\github\mitosis\nRF5_SDK_11\components\properitary_rf\gzll\iar\gzll_iar.a; D:\Projects\home\github\mitosis\nRF5_SDK_11\components\properitary_rf\gzll\iar\gzll_sd_resource_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../: main.c
  group Device
    ../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../components/toolchain/: system_nrf51.c
  group nRF_Drivers
    ../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../components/libraries/uart/: retarget.c app_uart_fifo.c
    ../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../components/libraries/fifo/: app_fifo.c
    ../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../components/drivers_nrf/rtc/: nrf_drv_rtc.c
    ../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c
