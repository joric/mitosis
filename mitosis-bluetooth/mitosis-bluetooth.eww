<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\mitosis\s130\iar\mitosis_bluetooth_s130.ewp</path>
  </project>
  <batchBuild/>
</workspace>