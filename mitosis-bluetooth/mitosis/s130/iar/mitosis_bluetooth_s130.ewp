# IAR project mitosis_bluetooth_s130.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF51822-QFAA NordicSemi nRF51822-QFAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; S130; COMPILE_REVERSED; SOFTDEVICE_PRESENT; NRF51; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\..\config\ble_app_hids_keyboard_s130_custom; ..\..\..\config; ..\..\..\..\..\components\ble\ble_advertising; ..\..\..\..\..\components\ble\ble_services\ble_bas; ..\..\..\..\..\components\ble\ble_services\ble_dis; ..\..\..\..\..\components\ble\ble_services\ble_hids; ..\..\..\..\..\components\ble\ble_services\ble_nus; ..\..\..\..\..\components\ble\common; ..\..\..\..\..\components\ble\device_manager; ..\..\..\..\..\components\device; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\pstorage; ..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\components\drivers_nrf\rtc; ..\..\..\..\..\components\libraries\button; ..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\components\libraries\fstorage\config; ..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\libraries\gpiote; ..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\components\softdevice\s130\headers; ..\..\..\..\..\components\softdevice\s130\headers\nrf51; ..\..\..\..\..\components\toolchain; ..\..\..\..\..\components\toolchain\CMSIS\Include; ..\..\..\..\..\components\properitary_rf\gzll
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BLE_STACK_SUPPORT_REQD; S130; BOARD_CUSTOM; SOFTDEVICE_PRESENT; NRF51; SWI_DISABLE0
  AARM.AUserIncludes: ..\..\..\config\ble_app_hids_keyboard_s130_custom; ..\..\..\config; ..\..\..\..\..\components\ble\ble_advertising; ..\..\..\..\..\components\ble\ble_services\ble_bas; ..\..\..\..\..\components\ble\ble_services\ble_dis; ..\..\..\..\..\components\ble\ble_services\ble_hids; ..\..\..\..\..\components\ble\common; ..\..\..\..\..\components\ble\device_manager; ..\..\..\..\..\components\device; ..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\components\drivers_nrf\config; ..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\drivers_nrf\pstorage; ..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\components\libraries\button; ..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\components\libraries\fstorage\config; ..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\components\libraries\trace; ..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\components\softdevice\s130\headers; ..\..\..\..\..\components\softdevice\s130\headers\nrf51; ..\..\..\..\..\components\toolchain; ..\..\..\..\..\components\toolchain\CMSIS\Include
  OBJCOPY.OOCOutputFile: ble_app_hids_keyboard_s130_custom.hex
  postbuild: D:\Projects\mitosis-keyboard\nRF5_SDK_11\mitosis\mitosis-bluetooth\program.cmd
  ILINK.IlinkOutputFile: ble_app_hids_keyboard_s130_custom.out
  ILINK.IlinkIcfFile: mitosis_bluetooth_iar_nRF5x.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\components\properitary_rf\gzll\iar\gzll_iar.a; ..\..\..\..\..\components\properitary_rf\gzll\iar\gzll_sd_resource_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; S130; BOARD_CUSTOM; SOFTDEVICE_PRESENT; NRF51; SWI_DISABLE0; NRF_LOG_USES_UART=1
  AARM.ADefines: BLE_STACK_SUPPORT_REQD; S130; SOFTDEVICE_PRESENT; NRF51; SWI_DISABLE0; NRF_LOG_USES_UART=1
  group Application
    ../../../: app_timer_qdec.c keymap.c main.c
  group Device
    ../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../components/toolchain/: system_nrf51.c
  group nRF_BLE
    ../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../../components/ble/ble_services/ble_hids/: ble_hids.c
    ../../../../../components/ble/ble_services/ble_nus/: ble_nus.c
    ../../../../../components/ble/device_manager/: device_manager_peripheral.c
  group nRF_Drivers
    ../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../components/libraries/util/: app_util_platform.c
    ../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c
    ../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/util/: app_error.c app_error_weak.c nrf_assert.c
    ../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../components/libraries/timer/: app_timer_appsh.c
    ../../../../../components/libraries/trace/: app_trace.c
    ../../../../../components/libraries/fstorage/: fstorage.c
    ../../../../../components/libraries/uart/: retarget.c
  group nRF_SoftDevice
    ../../../../../components/softdevice/s130/doc/: s130_nrf51_2.0.0_licence_agreement.txt
    ../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
